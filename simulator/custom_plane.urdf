Commit message: PPO, A2C categorize

File: simulator/custom_plane.urdf (robot description, URDF)
Before this commit: robot plane, 4 links, 3 joints
Links:
- link planeLink: geometry collision box size=60 30 10; visual mesh filename=custom_plane.obj scale=1 1 1
